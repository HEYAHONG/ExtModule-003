# Keil uVision project base.uvprojx, settings and files
target base (6240000::V6.24::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,PY32F030x8,HBOX_CONFIG_HEADER=hbox_port.h,FORBID_VECT_TAB_MIGRATION=1
  c include: ..\..\3rdparty\PY32F0xx_Firmware_V1.4.7\Drivers\CMSIS\Include;..\..\3rdparty\PY32F0xx_Firmware_V1.4.7\Drivers\PY32F0xx_HAL_Driver\Inc;..\..\3rdparty\PY32F0xx_Firmware_V1.4.7\Drivers\CMSIS\Device\PY32F0xx\Include;..\..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\;..\..\3rdparty\HCppBox\master\hbox;..\..\3rdparty\HCppBox\master\hbox\cpp;..\..\3rdparty\HCppBox\master\hbox\hstandalone\hopenblt\port;..\..\3rdparty\HCppBox\master\hbox\hstandalone\hopenblt\3rdparty
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f030xx.s
    ../: system_py32f0xx.c
  group Application/User
    ../: main.c py32f0xx_hal_msp.c py32f0xx_it.c drv_watchdog.c drv_softspi_xl2400p.c drv_led.c drv_psram.c drv_uart.c app_main.c openblt_port.c
    ./: syscalls.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../3rdparty/PY32F0xx_Firmware_V1.4.7/Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c py32f0xx_ll_utils.c
  group HBox
    ../../3rdparty/HCppBox/master/hbox/: h3rdparty.c hcompiler.c hcrypto.c hdefaults.c hdriverframework.c hevent.c hgui.c hlocale.c hmemory.c hnet.c hruntime.c hshell.c hsimulator.c huuid.c
    ../: hbox_port.c
  group HBox_3rdparty
    ../../3rdparty/HCppBox/master/hbox/h3rdparty/: h3rdparty_cjson.c h3rdparty_cjsonutils.c h3rdparty_freebsd_elf_header.c h3rdparty_mqtt_packet.c h3rdparty_pb_common.c h3rdparty_pb_decode.c h3rdparty_pb_encode.c h3rdparty_printf.c h3rdparty_softfloat.c h3rdparty_softfp.c h3rdparty_zlib_adler32.c h3rdparty_zlib_compress.c h3rdparty_zlib_crc32.c h3rdparty_zlib_deflate.c h3rdparty_zlib_infback.c h3rdparty_zlib_inffast.c h3rdparty_zlib_inflate.c h3rdparty_zlib_inftrees.c h3rdparty_zlib_trees.c h3rdparty_zlib_uncompr.c h3rdparty_zlib_zutil.c h3rdparty_lz4_lz4.c h3rdparty_lz4_lz4hc.c h3rdparty_common.c h3rdparty_zlib_gzclose.c h3rdparty_zlib_gzlib.c h3rdparty_zlib_gzread.c h3rdparty_zlib_gzwrite.c h3rdparty_libqrencode_bitstream.c h3rdparty_libqrencode_mask.c h3rdparty_libqrencode_mmask.c h3rdparty_libqrencode_mqrspec.c h3rdparty_libqrencode_qrencode.c h3rdparty_libqrencode_qrinput.c h3rdparty_libqrencode_qrspec.c h3rdparty_libqrencode_rsecc.c h3rdparty_libqrencode_split.c h3rdparty_argtable3_arg_cmd.c h3rdparty_argtable3_arg_date.c h3rdparty_argtable3_arg_dbl.c h3rdparty_argtable3_arg_dstr.c h3rdparty_argtable3_arg_end.c h3rdparty_argtable3_arg_file.c h3rdparty_argtable3_arg_getopt_long.c h3rdparty_argtable3_arg_hashtable.c h3rdparty_argtable3_arg_int.c h3rdparty_argtable3_arg_lit.c h3rdparty_argtable3_arg_rem.c h3rdparty_argtable3_arg_rex.c h3rdparty_argtable3_arg_str.c h3rdparty_argtable3_arg_utils.c h3rdparty_argtable3_argtable3.c h3rdparty_lz4_lz4file.c h3rdparty_lz4_lz4frame.c h3rdparty_lz4_xxhash.c h3rdparty_tlsf_tlsf.c h3rdparty_libfdt_fdt.c h3rdparty_libfdt_fdt_addresses.c h3rdparty_libfdt_fdt_check.c h3rdparty_libfdt_fdt_empty_tree.c h3rdparty_libfdt_fdt_overlay.c h3rdparty_libfdt_fdt_ro.c h3rdparty_libfdt_fdt_rw.c h3rdparty_libfdt_fdt_strerror.c h3rdparty_libfdt_fdt_sw.c h3rdparty_libfdt_fdt_wip.c h3rdparty_freertos_kernel_croutine.c h3rdparty_freertos_kernel_event_groups.c h3rdparty_freertos_kernel_heap.c h3rdparty_freertos_kernel_list.c h3rdparty_freertos_kernel_queue.c h3rdparty_freertos_kernel_stream_buffer.c h3rdparty_freertos_kernel_tasks.c h3rdparty_freertos_kernel_timers.c h3rdparty_cjson_port.c h3rdparty_libfdt_port.c h3rdparty_libqrencode_port.c h3rdparty_lz4_port.c h3rdparty_pb_port_msg_main_entry.c h3rdparty_tlsf_port.c h3rdparty_uriparser_UriCommon.c h3rdparty_uriparser_UriCompare.c h3rdparty_uriparser_UriCopy.c h3rdparty_uriparser_UriEscape.c h3rdparty_uriparser_UriFile.c h3rdparty_uriparser_UriIp4.c h3rdparty_uriparser_UriIp4Base.c h3rdparty_uriparser_UriMemory.c h3rdparty_uriparser_UriNormalize.c h3rdparty_uriparser_UriNormalizeBase.c h3rdparty_uriparser_UriParse.c h3rdparty_uriparser_UriParseBase.c h3rdparty_uriparser_UriQuery.c h3rdparty_uriparser_UriRecompose.c h3rdparty_uriparser_UriResolve.c h3rdparty_uriparser_UriSetFragment.c h3rdparty_uriparser_UriSetHostAuto.c h3rdparty_uriparser_UriSetHostCommon.c h3rdparty_uriparser_UriSetHostIp4.c h3rdparty_uriparser_UriSetHostIp6.c h3rdparty_uriparser_UriSetHostIpFuture.c h3rdparty_uriparser_UriSetHostRegName.c h3rdparty_uriparser_UriSetPath.c h3rdparty_uriparser_UriSetPort.c h3rdparty_uriparser_UriSetQuery.c h3rdparty_uriparser_UriSetScheme.c h3rdparty_uriparser_UriSetUserInfo.c h3rdparty_uriparser_UriShorten.c h3rdparty_uriparser_UriVersion.c h3rdparty_zlib_port.c h3rdparty_mini-rv32ima_port.c h3rdparty_Z80_port.c h3rdparty_Z80_Z80.c h3rdparty_uriparser_port.c
  group HBox_cpp
    ../../3rdparty/HCppBox/master/hbox/cpp/: hchain.cpp hcpprt.cpp hfifo.cpp hloop.cpp hobj.cpp hsim.cpp hslots.cpp hsoftdog.cpp
  group openblt
    ../../3rdparty/HCppBox/master/hbox/hstandalone/hopenblt/3rdparty/: asserts.c backdoor.c boot.c com.c cop.c events.c file.c infotable.c mb.c net.c xcp.c
    ../../3rdparty/HCppBox/master/hbox/hstandalone/hopenblt/port/: cpu.c file_patch.c net_patch.c nvm.c timer.c
software components: CMSIS:CORE 5.3.0
